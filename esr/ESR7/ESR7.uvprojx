# Keil uVision project ESR7.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ESR7
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: D:\Apps\Keil_v5\ARM\RV31\INC;D:\Apps\Keil_v5\ARM\INC\Philips
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Source Group 1
    ./: main.c
